Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_80.314_TORNEIRA_SENSOR_CLINICAL_MIX_PAREDE.IFC
Time: 2023-07-05T13:26:20
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_80.314_TAMPA_LATERAL_SEM_FURO
In: Default Storey
Material: Latão
